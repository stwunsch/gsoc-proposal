<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimator_factor</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rel_threshold</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_compare</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_protect</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>6e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_dec</value></param>
<param><key>value</key><value>samp_rate/decimator_factor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len_dec</value></param>
<param><key>value</key><value>packet_len/decimator_factor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>125000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>avg_mult</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>radar_signal_generator_cw_c</key>
<param><key>id</key><value>radar_signal_generator_cw_c_0</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>ampl</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>radar_os_cfar_c</key>
<param><key>id</key><value>radar_os_cfar_c_0</value></param>
<param><key>samp_rate</key><value>samp_rate_dec</value></param>
<param><key>samp_compare</key><value>samp_compare</value></param>
<param><key>samp_protect</key><value>samp_protect</value></param>
<param><key>rel_threshold</key><value>rel_threshold</value></param>
<param><key>avg_mult</key><value>avg_mult</value></param>
</block>
<block>
<key>radar_simulator_cc</key>
<param><key>id</key><value>radar_simulator_cc_0</value></param>
<param><key>rng</key><value>[0,0,0,0,0]</value></param>
<param><key>vlc</key><value>[-10,-5,0,3,8]</value></param>
<param><key>rcs</key><value>[1e9,1e9,1e9,1e9,1e9]</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>noise</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>radar_est_v_cw</key>
<param><key>id</key><value>radar_est_v_cw_0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
</block>
<block>
<key>radar_tsfft_cc</key>
<param><key>id</key><value>radar_tsfft_cc_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate_dec</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>packet_len_dec</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>radar_decimator_cc</key>
<param><key>id</key><value>radar_decimator_cc_0</value></param>
<param><key>dec_factor</key><value>decimator_factor</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>radar_os_cfar_c_0</source_block_id><sink_block_id>radar_est_v_cw_0</sink_block_id><source_key>cfar_out</source_key><sink_key>cw_in</sink_key></connection>
<connection><source_block_id>radar_tsfft_cc_0</source_block_id><sink_block_id>radar_os_cfar_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>radar_signal_generator_cw_c_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>radar_simulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_simulator_cc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>radar_decimator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_decimator_cc_0</source_block_id><sink_block_id>radar_tsfft_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_decimator_cc_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
