<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_block</value></param>
<param><key>value</key><value>2**10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a</value></param>
<param><key>value</key><value>(8*fd)/(Tr*c)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c</value></param>
<param><key>value</key><value>3e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_max</value></param>
<param><key>value</key><value>samp_rate/2-freq_min</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_min</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fUp</value></param>
<param><key>value</key><value>((2*fd)/Tr)*((2*R)/c)-fD</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>125e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fDown</value></param>
<param><key>value</key><value>-((2*fd)/Tr)*((2*R)/c)-fD</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fD</value></param>
<param><key>value</key><value>(2*v*f0)/c</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>radar_FMCW_generate_IQ_cc</key>
<param><key>id</key><value>radar_FMCW_generate_IQ_cc_0</value></param>
<param><key>samp_block</key><value>samp_block</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>samp_block</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(samp_block)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>samp_block</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(samp_block)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>fUp</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>fD</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>fDown</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>samp_block</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(samp_block)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>radar_FMCW_separate_IQ_cc</key>
<param><key>id</key><value>radar_FMCW_separate_IQ_cc_0</value></param>
<param><key>samp_block</key><value>samp_block</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>R</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>40</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(1,1,1,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>v</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>5</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(2,1,1,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>f0</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>24.125e9</value></param>
<param><key>min</key><value>24e9</value></param>
<param><key>max</key><value>24.250e9</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(3,1,1,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fd</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>125e6</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>125e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(4,1,1,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>Tr</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>1e-3</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1e-1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(5,1,1,1)</value></param>
</block>
<block>
<key>radar_FFT_findpeak_max_vcf</key>
<param><key>id</key><value>radar_FFT_findpeak_max_vcf_0</value></param>
<param><key>samp_block</key><value>samp_block</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_min</key><value>freq_min</value></param>
<param><key>freq_max</key><value>freq_max</value></param>
</block>
<block>
<key>radar_FFT_findpeak_max_vcf</key>
<param><key>id</key><value>radar_FFT_findpeak_max_vcf_0_0</value></param>
<param><key>samp_block</key><value>samp_block</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_min</key><value>freq_min</value></param>
<param><key>freq_max</key><value>freq_max</value></param>
</block>
<block>
<key>radar_FFT_findpeak_max_vcf</key>
<param><key>id</key><value>radar_FFT_findpeak_max_vcf_0_1</value></param>
<param><key>samp_block</key><value>samp_block</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_min</key><value>freq_min</value></param>
<param><key>freq_max</key><value>freq_max</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1/a</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>R</value></param>
<param><key>units</key><value>m</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>40</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>10000</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>grid_pos</key><value>(1,2,1,1)</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>v</value></param>
<param><key>units</key><value>m/s</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>10</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>10000</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>grid_pos</key><value>(2,2,1,1)</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>c/(2*f0)</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>fUp</value></param>
<param><key>units</key><value>Hz</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-freq_min</value></param>
<param><key>max_value</key><value>freq_max</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>10000</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>grid_pos</key><value>(4,2,1,1)</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>fDown</value></param>
<param><key>units</key><value>Hz</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-freq_max</value></param>
<param><key>max_value</key><value>-freq_min</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>10000</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>grid_pos</key><value>(5,2,1,1)</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>fD</value></param>
<param><key>units</key><value>Hz</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>freq_min</value></param>
<param><key>max_value</key><value>2e3</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>10000</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>grid_pos</key><value>(3,2,1,1)</value></param>
</block>
<connection><source_block_id>radar_FMCW_generate_IQ_cc_0</source_block_id><sink_block_id>radar_FMCW_separate_IQ_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>blocks_throttle_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>radar_FMCW_generate_IQ_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>radar_FMCW_generate_IQ_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0_0</source_block_id><sink_block_id>radar_FMCW_generate_IQ_cc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>radar_FFT_findpeak_max_vcf_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>radar_FFT_findpeak_max_vcf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_FMCW_separate_IQ_cc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_FMCW_separate_IQ_cc_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_FMCW_separate_IQ_cc_0</source_block_id><sink_block_id>fft_vxx_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>radar_FFT_findpeak_max_vcf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_FFT_findpeak_max_vcf_0_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_1</source_block_id><sink_block_id>radar_FFT_findpeak_max_vcf_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_FFT_findpeak_max_vcf_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_numbersink2_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_FFT_findpeak_max_vcf_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_FFT_findpeak_max_vcf_0_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>wxgui_numbersink2_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_FFT_findpeak_max_vcf_0_1</source_block_id><sink_block_id>wxgui_numbersink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
